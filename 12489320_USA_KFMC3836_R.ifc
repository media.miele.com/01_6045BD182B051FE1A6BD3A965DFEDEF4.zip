Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 7a81b1c4-4a59-48b2-8550-230caf481047, NumberOfSaves: 1]
File name: 0001
Time: 2026-08-15T00:09:23+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12489320_USA_KFMC3836_R:38383600_USA_12489320_KFMC3836_R, (2)
In: Default
Type - Material: <Unnamed>, z_Miele_Design_OBSW, z_Miele_Connection_Connection_Modul, z_Miele_Connection_Connection_Water_IN
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 756 mm; Height: 2125 mm; Depth: 608 mm
Pset_BuildingElementProxyCommon - Reference: 38383600_USA_12489320_KFMC3836_R; sets with these values: 2
